# Keil uVision project electric_cars_iot.uvprojx, settings and files
target electric_cars_iot (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F030CCTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: electric_cars_iot +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030xC
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Drivers/CMSIS/Include;..\HARDWARE\USART;..\HARDWARE\IoT_Hub;..\HARDWARE\GPIO;..\PROTOCAL;..\HARDWARE\ADC;..\HARDWARE\EXTI;..\HARDWARE\VOICE;..\HARDWARE\KX023;..\HARDWARE\flash;..\HARDWARE\BLUETOOTH;..\BLUETOOTH;..\CONTROL;..\HARDWARE\queen;..\HARDWARE\queen_ext;..\HARDWARE\STMFLASH
  asm include: ..\Inc;..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f0xx_it.c freertos.c main.c stm32f0xx_hal_msp.c stm32f0xx_hal_timebase_TIM.c
  group Application/MDK-ARM
    ./: startup_stm32f030xc.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c tasks.c event_groups.c list.c queue.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_rcc.c stm32f0xx_hal_gpio.c stm32f0xx_hal_pwr.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_uart.c stm32f0xx_hal_i2c.c stm32f0xx_hal_dma.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_iwdg.c
  group HARDWARE
    ../HARDWARE/USART/: usart.c
    ../HARDWARE/GPIO/: GPIO.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/VOICE/: voice.c
    ../HARDWARE/flash/: flash.c
    ../HARDWARE/BLUETOOTH/: bluetooth.c
    ../HARDWARE/queen/: queen.c
    ../HARDWARE/IoT_Hub/: IoT_Hub.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/EPROM/: eprom.c
  group PROTOCAL
    ../PROTOCAL/: protocol.c
  group CONTROL
    ../CONTROL/: Control_app.c Control_interface.c factory_test.c
  group BLUETOOTH
    ../BLUETOOTH/: bt_app.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f0xx.c
software components: CMSIS:CORE 5.1.1
